# Repository NOVA-Cluster/Universal-Poofer-Control (continued)

## KiCad design Universal_Poofer_Control.kicad_pcb (continued)

Schematic: Stop_Field.kicad_sch, 15 | NC emergency-stop field loop

Parts:
C109: 10nF / 50V; C_0805_2012Metric; MPN CL21B103KBANNNC; LCSC C1710
C139: 100nF; C_0805_2012Metric; MPN CC0805KRX7R9BB104; LCSC C49678
C169: 1nF / 50V; C_0805_2012Metric; MPN CL21B102KBANNNC; LCSC C51210
D109, D119, D129: BAS21; SOT-23; MPN BAS21,215; LCSC C8661
D149: BAT54; SOT-23; MPN BAT54,215; LCSC C85084
J9, J10: 2P / 2.54mm; PinHeader_1x02_P2.54mm_Vertical; MPN B-2100S02P-A110; LCSC C124375
Q109: MJD350T4G; TO-252-3_TabPin2; MPN MJD350T4G; LCSC C145514
Q119, Q129: MMBT3904; SOT-23; MPN MMBT3904(RANGE:100-300); LCSC C20526
Q139: AO3401A; SOT-23; MPN AO3401A; LCSC C15127
Q149: AO3400A; SOT-23; MPN AO3400A; LCSC C20917
Q159: MMBT3906; SOT-23; MPN MMBT3906 2A(RANGE:100-300); LCSC C2143
R1240: 33R; R_0805_2012Metric; MPN 0805W8F330JT5E; LCSC C17634
R1241: 2.2k; R_0805_2012Metric; MPN 0805W8F2201T5E; LCSC C17520
R1242, R1243, R1262, R1263: 1k; R_0805_2012Metric; MPN 0805W8F1001T5E; LCSC C17513
R1244, R1245, R1246, R1247, R1249, R1250, R1251, R1252, R1254, R1255, R1256: 100k; R_0805_2012Metric; MPN 0805W8F1003T5E; LCSC C149504
R1248: 68k; R_0805_2012Metric; MPN 0805W8F6802T5E; LCSC C17801
R1253, R1260, R1261: 10k; R_0805_2012Metric; MPN 0805W8F1002T5E; LCSC C17414
R1257: 6.8k; R_0805_2012Metric; MPN 0805W8F6801T5E; LCSC C17772
R1258, R1259: 1M; R_0805_2012Metric; MPN 0805W8F1004T5E; LCSC C17514
U12: LM2901BIDR; SOIC-14_3.9x8.7mm_P1.27mm; MPN LM2901BIDR; LCSC C22427890
U22: LM2902DR; SOIC-14_3.9x8.7mm_P1.27mm; MPN LM2902DR; LCSC C350545

Connections:
+3V3: R1250.1, R1253.1, R1260.1; also elsewhere on the board
+5V_LOGIC: Q139.2 (S), Q159.2 (E), R1240.1, R1243.1, R1248.1, R1262.1; also elsewhere on the board
/15 | NC emergency-stop field loop/IN9_AMP_OUT: C139.1, R1241.2, U22.1
/15 | NC emergency-stop field loop/IN9_DRV_COL: Q119.3 (C), R1242.2
/15 | NC emergency-stop field loop/IN9_HYST_MID: R1258.2, R1259.1
/15 | NC emergency-stop field loop/IN9_UV_GATE: Q129.3 (C), Q139.1 (G), R1248.2
/15 | NC emergency-stop field loop/IN9_UV_SENSE: R1249.2, R1250.2, R1251.1, R1252.1, U12.6 (-)
/15 | NC emergency-stop field loop/IN9_WET_COLLECTOR: D109.1 (A), Q109.2 (C)
CONTACT_REF: U12.4 (-); also elsewhere on the board
CURRENT_REF: D149.1 (A), R1261.1; also elsewhere on the board
ESTOP_CHAIN_OUT: J9.2, J10.1; also elsewhere on the board
ESTOP_CLOSED_N: R1259.2, R1260.2, U12.2; also elsewhere on the board
ESTOP_FIELD: D109.3 (K), D119.1 (A), D129.3 (K), J9.1; also elsewhere on the board
ESTOP_UV_FAULT: R1253.2, U12.1; also elsewhere on the board
GND: C109.2, C169.2, J10.2, Q119.2 (E), Q129.1 (B), Q149.2 (S), R1247.2, R1251.2, R1252.2, R1257.2; also elsewhere on the board
IN9_AMP_REF: C139.2, D149.3 (K), R1261.2, U22.2 (-)
IN9_DRV_BASE: Q119.1 (B), Q149.3 (D), R1241.1
IN9_EMIT_F: U22.3 (+); also elsewhere on the board
IN9_LIMIT_BASE: Q159.1 (B), R1262.2, R1263.1
IN9_SENSE: C109.1, R1256.2, R1257.1, R1258.1, U12.5 (+)
IN9_UV_EMITTER: C169.1, Q129.2 (E), R1244.1, R1247.1, R1249.1
IN9_WET_BASE: Q109.1 (B), Q139.3 (D), Q159.3 (C), R1242.1, R1243.2
IN9_WET_EMIT: Q109.3 (E), R1240.2, R1263.2; also elsewhere on the board
LOCAL_MASTER_N: Q149.1 (G); also elsewhere on the board
unnamed: D119.3 (K), R1254.1
unnamed: D129.1 (A), R1246.2
unnamed: R1244.2, R1245.1
unnamed: R1245.2, R1246.1
unnamed: R1254.2, R1255.1
unnamed: R1255.2, R1256.1
UV_REF: U12.7 (+); also elsewhere on the board

Notes on the sheet:
UNIVERSAL POOFER CONTROL | 15 | NC emergency-stop field loop
REV A.3 | Dry contacts | Latched hardware stop | Buffered expansion
INPUT 9 | PRECISION WETTING SOURCE
Nominal 20 mA; compensated servo and backup limiter
AUTONOMOUS NEGATIVE-FAULT CLAMP
INPUT 9 | ACTIVE-LOW RECEIVER
LOW = closed; FAULT high masks invalid closure
PROTECTED FAULT FLAG
Four 100k conductances bias and attenuate emitter
ExactlyoneMASTERsuppliesloopwetting; all NC contacts and chainconnectors are in series.

Schematic: Relay_Outputs_1.kicad_sch, 16 | Valve outputs 1-4

Parts:
D11, D12, D13, D14: SS14; D_SMA; MPN SS14; LCSC C2480
D21, D22, D23, D24: 8.2V / 1W; D_SMA; MPN SMAZ8V2-13-F; LCSC C84362
D31, D32, D33, D34: SS34; D_SMA; MPN SS34; LCSC C8678
D41, D42, D43, D44: SMBJ8.0A; D_SMB; MPN SMBJ8.0A; LCSC C224028
J31, J32, J33, J34: 3P / 2.54mm; PinHeader_1x03_P2.54mm_Vertical; MPN B-2100S03P-A110; LCSC C124376
J41, J42, J43, J44: 2P / 2.54mm; PinHeader_1x02_P2.54mm_Vertical; MPN B-2100S02P-A110; LCSC C124375
K1, K2, K3, K4: SRD-12VDC-SL-C; Relay_SPDT_Songle_SRD; MPN SRD-12VDC-SL-C; LCSC C30431
Q1, Q2, Q3, Q4: AO3400A; SOT-23; MPN AO3400A; LCSC C20917
R201, R202, R203, R204: 100R; R_0805_2012Metric; MPN 0805W8F1000T5E; LCSC C17408
R211, R212, R213, R214: 100k; R_0805_2012Metric; MPN 0805W8F1003T5E; LCSC C149504

Connections:
+12V_COIL_SAFE: D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), K1.5, K2.5, K3.5, K4.5; also elsewhere on the board
/16 | Valve outputs 1-4/RLY1_COIL_CLAMP: D11.1 (K), D21.1 (K)
/16 | Valve outputs 1-4/RLY1_DRAIN: D11.2 (A), K1.2, Q1.3 (D)
/16 | Valve outputs 1-4/RLY1_GATE: Q1.1 (G), R201.2, R211.1
/16 | Valve outputs 1-4/RLY2_COIL_CLAMP: D12.1 (K), D22.1 (K)
/16 | Valve outputs 1-4/RLY2_DRAIN: D12.2 (A), K2.2, Q2.3 (D)
/16 | Valve outputs 1-4/RLY2_GATE: Q2.1 (G), R202.2, R212.1
/16 | Valve outputs 1-4/RLY3_COIL_CLAMP: D13.1 (K), D23.1 (K)
/16 | Valve outputs 1-4/RLY3_DRAIN: D13.2 (A), K3.2, Q3.3 (D)
/16 | Valve outputs 1-4/RLY3_GATE: Q3.1 (G), R203.2, R213.1
/16 | Valve outputs 1-4/RLY4_COIL_CLAMP: D14.1 (K), D24.1 (K)
/16 | Valve outputs 1-4/RLY4_DRAIN: D14.2 (A), K4.2, Q4.3 (D)
/16 | Valve outputs 1-4/RLY4_GATE: Q4.1 (G), R204.2, R214.1
/16 | Valve outputs 1-4/VALVE1_CLAMP: D31.1 (K), D41.1 (K)
/16 | Valve outputs 1-4/VALVE2_CLAMP: D32.1 (K), D42.1 (K)
/16 | Valve outputs 1-4/VALVE3_CLAMP: D33.1 (K), D43.1 (K)
/16 | Valve outputs 1-4/VALVE4_CLAMP: D34.1 (K), D44.1 (K)
GND: Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R211.2, R212.2, R213.2, R214.2; also elsewhere on the board
RLY1_CMD: R201.1; also elsewhere on the board
RLY2_CMD: R202.1; also elsewhere on the board
RLY3_CMD: R203.1; also elsewhere on the board
RLY4_CMD: R204.1; also elsewhere on the board
VALVE1_COM: J31.1, K1.1
VALVE1_NC_AUX: J31.3, K1.3
VALVE1_NO: D41.2 (A), J31.2, J41.1, K1.4
VALVE1_RETURN: D31.2 (A), J41.2
VALVE2_COM: J32.1, K2.1
VALVE2_NC_AUX: J32.3, K2.3
VALVE2_NO: D42.2 (A), J32.2, J42.1, K2.4
VALVE2_RETURN: D32.2 (A), J42.2
VALVE3_COM: J33.1, K3.1
VALVE3_NC_AUX: J33.3, K3.3
VALVE3_NO: D43.2 (A), J33.2, J43.1, K3.4
VALVE3_RETURN: D33.2 (A), J43.2
VALVE4_COM: J34.1, K4.1
VALVE4_NC_AUX: J34.3, K4.3
VALVE4_NO: D44.2 (A), J34.2, J44.1, K4.4
VALVE4_RETURN: D34.2 (A), J44.2

Notes on the sheet:
UNIVERSAL POOFER CONTROL | 16 | Valve outputs 1-4
REV A.3 | Dry contacts | Latched hardware stop | Buffered expansion
VALVE 1 | NO OUTPUT
12 VDC / 1 A; fast release clamps; NC auxiliary
VALVE 2 | NO OUTPUT
VALVE 3 | NO OUTPUT
VALVE 4 | NO OUTPUT

Schematic: Relay_Outputs_2.kicad_sch, 17 | Valve outputs 5-8

Parts:
D15, D16, D17, D18: SS14; D_SMA; MPN SS14; LCSC C2480
D25, D26, D27, D28: 8.2V / 1W; D_SMA; MPN SMAZ8V2-13-F; LCSC C84362
D35, D36, D37, D38: SS34; D_SMA; MPN SS34; LCSC C8678
D45, D46, D47, D48: SMBJ8.0A; D_SMB; MPN SMBJ8.0A; LCSC C224028
J35, J36, J37, J38: 3P / 2.54mm; PinHeader_1x03_P2.54mm_Vertical; MPN B-2100S03P-A110; LCSC C124376
J45, J46, J47, J48: 2P / 2.54mm; PinHeader_1x02_P2.54mm_Vertical; MPN B-2100S02P-A110; LCSC C124375
K5, K6, K7, K8: SRD-12VDC-SL-C; Relay_SPDT_Songle_SRD; MPN SRD-12VDC-SL-C; LCSC C30431
Q5, Q6, Q7, Q8: AO3400A; SOT-23; MPN AO3400A; LCSC C20917
R205, R206, R207, R208: 100R; R_0805_2012Metric; MPN 0805W8F1000T5E; LCSC C17408
R215, R216, R217, R218: 100k; R_0805_2012Metric; MPN 0805W8F1003T5E; LCSC C149504

Connections:
+12V_COIL_SAFE: D25.2 (A), D26.2 (A), D27.2 (A), D28.2 (A), K5.5, K6.5, K7.5, K8.5; also elsewhere on the board
/17 | Valve outputs 5-8/RLY5_COIL_CLAMP: D15.1 (K), D25.1 (K)
/17 | Valve outputs 5-8/RLY5_DRAIN: D15.2 (A), K5.2, Q5.3 (D)
/17 | Valve outputs 5-8/RLY5_GATE: Q5.1 (G), R205.2, R215.1
/17 | Valve outputs 5-8/RLY6_COIL_CLAMP: D16.1 (K), D26.1 (K)
/17 | Valve outputs 5-8/RLY6_DRAIN: D16.2 (A), K6.2, Q6.3 (D)
/17 | Valve outputs 5-8/RLY6_GATE: Q6.1 (G), R206.2, R216.1
/17 | Valve outputs 5-8/RLY7_COIL_CLAMP: D17.1 (K), D27.1 (K)
/17 | Valve outputs 5-8/RLY7_DRAIN: D17.2 (A), K7.2, Q7.3 (D)
/17 | Valve outputs 5-8/RLY7_GATE: Q7.1 (G), R207.2, R217.1
/17 | Valve outputs 5-8/RLY8_COIL_CLAMP: D18.1 (K), D28.1 (K)
/17 | Valve outputs 5-8/RLY8_DRAIN: D18.2 (A), K8.2, Q8.3 (D)
/17 | Valve outputs 5-8/RLY8_GATE: Q8.1 (G), R208.2, R218.1
/17 | Valve outputs 5-8/VALVE5_CLAMP: D35.1 (K), D45.1 (K)
/17 | Valve outputs 5-8/VALVE6_CLAMP: D36.1 (K), D46.1 (K)
/17 | Valve outputs 5-8/VALVE7_CLAMP: D37.1 (K), D47.1 (K)
/17 | Valve outputs 5-8/VALVE8_CLAMP: D38.1 (K), D48.1 (K)
GND: Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), R215.2, R216.2, R217.2, R218.2; also elsewhere on the board
RLY5_CMD: R205.1; also elsewhere on the board
RLY6_CMD: R206.1; also elsewhere on the board
RLY7_CMD: R207.1; also elsewhere on the board
RLY8_CMD: R208.1; also elsewhere on the board
VALVE5_COM: J35.1, K5.1
VALVE5_NC_AUX: J35.3, K5.3
VALVE5_NO: D45.2 (A), J35.2, J45.1, K5.4
VALVE5_RETURN: D35.2 (A), J45.2
VALVE6_COM: J36.1, K6.1
VALVE6_NC_AUX: J36.3, K6.3
VALVE6_NO: D46.2 (A), J36.2, J46.1, K6.4
VALVE6_RETURN: D36.2 (A), J46.2
VALVE7_COM: J37.1, K7.1
VALVE7_NC_AUX: J37.3, K7.3
VALVE7_NO: D47.2 (A), J37.2, J47.1, K7.4
VALVE7_RETURN: D37.2 (A), J47.2
VALVE8_COM: J38.1, K8.1
VALVE8_NC_AUX: J38.3, K8.3
VALVE8_NO: D48.2 (A), J38.2, J48.1, K8.4
VALVE8_RETURN: D38.2 (A), J48.2

Notes on the sheet:
UNIVERSAL POOFER CONTROL | 17 | Valve outputs 5-8
REV A.3 | Dry contacts | Latched hardware stop | Buffered expansion
VALVE 5 | NO OUTPUT
12 VDC / 1 A; fast release clamps; NC auxiliary
VALVE 6 | NO OUTPUT
VALVE 7 | NO OUTPUT
VALVE 8 | NO OUTPUT

Schematic: Analog_Support.kicad_sch, 18 | Analog supplies, spare units and debug port

Parts:
C80, C81, C82, C83, C84, C90, C91, C92: 100nF; C_0805_2012Metric; MPN CC0805KRX7R9BB104; LCSC C49678
J5: 20P / 2.54mm; PinHeader_1x20_P2.54mm_Vertical; MPN 2.54-1*20P; LCSC C50981
U10, U11, U12, U13, U14: LM2901BIDR; SOIC-14_3.9x8.7mm_P1.27mm; MPN LM2901BIDR; LCSC C22427890
U20, U21, U22: LM2902DR; SOIC-14_3.9x8.7mm_P1.27mm; MPN LM2902DR; LCSC C350545

Connections:
+3V3: J5.2; also elsewhere on the board
+5V_LOGIC: J5.3; also elsewhere on the board
+12V_IN: C80.1, C81.1, C82.1, C83.1, C84.1, C90.1, C91.1, C92.1, J5.4, U10.3 (V+), U11.3 (V+), U12.3 (V+), U13.3 (V+), U14.3 (V+), U20.4 (V+), U21.4 (V+), U22.4 (V+); also elsewhere on the board
BUS_CLK: J5.5; also elsewhere on the board
BUS_CLR_N: J5.8; also elsewhere on the board
BUS_LATCH: J5.7; also elsewhere on the board
BUS_LOAD_N: J5.6; also elsewhere on the board
CONTACT_REF: U12.8 (-), U12.10 (-); also elsewhere on the board
ESTOP_SAFE_MON_GPIO18: J5.11; also elsewhere on the board
GND: C80.2, C81.2, C82.2, C83.2, C84.2, C90.2, C91.2, C92.2, J5.1, U10.12 (V-), U11.12 (V-), U12.9 (+), U12.11 (+), U12.12 (V-), U13.12 (V-), U14.12 (V-), U20.11 (V-), U21.11 (V-), U22.10 (+), U22.11 (V-), U22.12 (+); also elsewhere on the board
HW_RUN_MON_GPIO21: J5.10; also elsewhere on the board
unnamed: U22.8, U22.9 (-)
unnamed: U22.13 (-), U22.14
OE_MONITOR_N: J5.9; also elsewhere on the board
RLY1_CMD: J5.13; also elsewhere on the board
RLY2_CMD: J5.14; also elsewhere on the board
RLY3_CMD: J5.15; also elsewhere on the board
RLY4_CMD: J5.16; also elsewhere on the board
RLY5_CMD: J5.17; also elsewhere on the board
RLY6_CMD: J5.18; also elsewhere on the board
RLY7_CMD: J5.19; also elsewhere on the board
RLY8_CMD: J5.20; also elsewhere on the board
ROLE_GPIO2_MON: J5.12; also elsewhere on the board

Notes on the sheet:
UNIVERSAL POOFER CONTROL | 18 | Analog supplies, spare units and debug port
REV A.3 | Dry contacts | Latched hardware stop | Buffered expansion
COMPARATOR BANK SUPPLIES
One 100 nF bypass per physical IC; raw12V supply
CURRENT-SERVO SUPPLIES
Defined unused amplifiers; no floating inputs
DEBUG / COMMAND BREAKOUT
Power pins identified; monitor nodes isolated
DEFINED UNUSED COMPARATORS

Schematic: Logic_Support.kicad_sch, 19 | Safety logic supplies and unused gates

Parts:
C110, C111, C112, C113: 100nF; C_0805_2012Metric; MPN CC0805KRX7R9BB104; LCSC C49678
R136: 100k; R_0805_2012Metric; MPN 0805W8F1003T5E; LCSC C149504
U30: 74HC00D,653; SOIC-14_3.9x8.7mm_P1.27mm; MPN 74HC00D,653; LCSC C5586
U31: 74HC02D,653; SOIC-14_3.9x8.7mm_P1.27mm; MPN 74HC02D,653; LCSC C5588
U32: 74HC14D,653; SOIC-14_3.9x8.7mm_P1.27mm; MPN 74HC14D,653; LCSC C5605
U34: 74HC74D,653; SOIC-14_3.9x8.7mm_P1.27mm; MPN 74HC74D,653; LCSC C27597

Connections:
+3V3: C110.1, C111.1, C112.1, C113.1, U30.14 (VCC), U31.14 (VCC), U32.14 (VCC), U34.10 (~S), U34.14 (VCC); also elsewhere on the board
GND: C110.2, C111.2, C112.2, C113.2, U30.1, U30.2, U30.4, U30.5, U30.7 (GND), U30.9, U30.10, U31.7 (GND), U31.11, U31.12, U32.3, U32.7 (GND), U32.13, U34.7 (GND), U34.11 (C), U34.12 (D), U34.13 (~R); also elsewhere on the board
OE_MONITOR_N: R136.2; also elsewhere on the board
RLY_OE_ACTUAL_N: R136.1; also elsewhere on the board

Notes on the sheet:
UNIVERSAL POOFER CONTROL | 19 | Safety logic supplies and unused gates
REV A.3 | Dry contacts | Latched hardware stop | Buffered expansion
SAFETY LOGIC SUPPLIES
Local 3.3V rail; 100nF at each package
DEFINED SPARE GATES
No floating CMOS inputs; unused outputs left open

Schematic: Current_Reference.kicad_sch, 20 | Buffered current reference and rail sequencing

Parts:
C66: 10uF / 25V; C_0805_2012Metric; MPN CL21A106KAYNNNE; LCSC C15850
R66, R67: 100R; R_0805_2012Metric; MPN 0805W8F1000T5E; LCSC C17408
U22: LM2902DR; SOIC-14_3.9x8.7mm_P1.27mm; MPN LM2902DR; LCSC C350545

Connections:
CURRENT_REF: C66.1, R67.2; also elsewhere on the board
CURRENT_REF_DRIVE: R66.1, U22.6 (-), U22.7
CURRENT_REF_RAW: U22.5 (+); also elsewhere on the board
GND: C66.2; also elsewhere on the board
unnamed: R66.2, R67.1

Notes on the sheet:
UNIVERSAL POOFER CONTROL | 20 | Buffered current reference and rail sequencing
REV A.3 | Dry contacts | Latched hardware stop | Buffered expansion
LOW-IMPEDANCE SHARED REFERENCE
SpareU22B isolates all nine compensated source loops
200ohm total bounds initial10uF discharge near22mA. Output behavior whenunpowered requireshardwarequalification.
Per-source10k/100nF compensation uses a private negative-input node; never attach it directly to the rawdivider.
Backup PNP limiters bound saturation recovery current. Power-good holds coiloutputs off through settling.

Schematic: I2C_Expansion.kicad_sch, 21 | I2C expansion and power-off isolation

Parts:
C74, C75: 100nF; C_0805_2012Metric; MPN CC0805KRX7R9BB104; LCSC C49678
JP2: 2P / 2.54mm; PinHeader_1x02_P2.54mm_Vertical; MPN B-2100S02P-A110; LCSC C124375
R120, R121: 2.2k; R_0805_2012Metric; MPN 0805W8F2201T5E; LCSC C17520
R122, R123: 4.7k; R_0805_2012Metric; MPN 0805W8F4701T5E; LCSC C17673
U54: PCA9517AD; SOIC-8_3.9x4.9mm_P1.27mm; MPN PCA9517AD,118; LCSC C2802638

Connections:
+3V3: C74.1, C75.1, JP2.1, R122.1, R123.1, U54.1 (VCCA), U54.8 (VCCB); also elsewhere on the board
GND: C74.2, C75.2, U54.4 (GND); also elsewhere on the board
I2C_PULLUP_RAIL: JP2.2, R120.1, R121.1
I2C_SCL_BUS: R121.2, U54.2 (SCLA); also elsewhere on the board
I2C_SCL_GPIO9: R123.2, U54.7 (SCLB); also elsewhere on the board
I2C_SDA_BUS: R120.2, U54.3 (SDAA); also elsewhere on the board
I2C_SDA_GPIO8: R122.2, U54.6 (SDAB); also elsewhere on the board
PG_RESET_N: U54.5 (EN); also elsewhere on the board

Notes on the sheet:
UNIVERSAL POOFER CONTROL | 21 | I2C expansion and power-off isolation
REV A.3 | Dry contacts | Latched hardware stop | Buffered expansion
COMMON A BUS / PRIVATE B BUS
AllA sides may share the bus; B sides must remain private
Pins15SDA,16SCL on both chain ports. Default 100 kHz; qualify totalcommon-A capacitance<=400pF.
32 A ports can contribute224pF before cabling.2.2k commonpullups meet the conservativeleakage/high-levelbudget.
MCU B-side LOW mustbe<=0.4V; bufferedLOW<=0.6V remainsbelowESP VIL. Testload/temperaturecorners.

Schematic: Expansion_Bias.kicad_sch, 22 | Expansion defaults and buffer supplies

Parts:
C70, C71, C72: 100nF; C_0805_2012Metric; MPN CC0805KRX7R9BB104; LCSC C49678
R88, R90, R91, R92, R93, R94, R95, R124, R125, R126, R127, R128, R129, R130, R131, R132, R133, R134, R135: 10k; R_0805_2012Metric; MPN 0805W8F1002T5E; LCSC C17414

Connections:
+3V3: C70.1, C71.1, C72.1, R88.1, R93.1, R94.1, R127.1, R128.1, R133.1, R134.1; also elsewhere on the board
BUS_ARM_N: R93.2; also elsewhere on the board
BUS_CLK: R90.2; also elsewhere on the board
BUS_CLR_N: R92.2; also elsewhere on the board
BUS_LATCH: R91.2; also elsewhere on the board
BUS_LOAD_N: R94.2; also elsewhere on the board
BUS_SER_IN: R95.2; also elsewhere on the board
DOWN_RETURN: R88.2; also elsewhere on the board
GND: C70.2, C71.2, C72.2, R90.1, R91.1, R92.1, R95.1, R124.1, R125.1, R126.1, R129.1, R130.1, R131.1, R132.1, R135.1; also elsewhere on the board
MCU_CLK_GPIO6: R130.2; also elsewhere on the board
MCU_CLR_N_GPIO16: R132.2; also elsewhere on the board
MCU_INHIBIT_N_GPIO15: R133.2; also elsewhere on the board
MCU_LATCH_GPIO7: R131.2; also elsewhere on the board
MCU_LOAD_N_GPIO17: R134.2; also elsewhere on the board
MCU_MOSI_GPIO4: R135.2; also elsewhere on the board
UP_ARM_N: R127.2; also elsewhere on the board
UP_CLK: R124.2; also elsewhere on the board
UP_CLR_N: R126.2; also elsewhere on the board
UP_LATCH: R125.2; also elsewhere on the board
UP_LOAD_N: R128.2; also elsewhere on the board
UP_SER: R129.2; also elsewhere on the board

Notes on the sheet:
UNIVERSAL POOFER CONTROL | 22 | Expansion defaults and buffer supplies
REV A.3 | Dry contacts | Latched hardware stop | Buffered expansion
DEFINED COMMAND DEFAULTS
BUS / UP / LOCAL rows: safe receiver inputs even if MCU never boots or cable is absent
CHAIN TAIL / LOCAL BYPASS
Tail HIGH fills missing-module fault bits with FF; firmware masks these input bytes
Keep each 100nF physically beside its LVC244 VCC pin; no supply is shared by the expansion connectors.

Schematic: Rail_Supervision.kicad_sch, 23 | Hardware monitoring of 5V and raw 12V

Parts:
C154: 100nF; C_0805_2012Metric; MPN CC0805KRX7R9BB104; LCSC C49678
C156: 10nF / 50V; C_0805_2012Metric; MPN CL21B103KBANNNC; LCSC C1710
R137, R138, R139, R140: 1k; R_0805_2012Metric; MPN 0805W8F1001T5E; LCSC C17513
R151, R152, R154: 100k; R_0805_2012Metric; MPN 0805W8F1003T5E; LCSC C149504
R153, R155, R157: 10k; R_0805_2012Metric; MPN 0805W8F1002T5E; LCSC C17414
R156: 68k; R_0805_2012Metric; MPN 0805W8F6802T5E; LCSC C17801
R158: 1M; R_0805_2012Metric; MPN 0805W8F1004T5E; LCSC C17514
U35: TLV9022DR; SOIC-8_3.9x4.9mm_P1.27mm; MPN TLV9022DR; LCSC C2871718

Connections:
+3V3: C154.1, R140.1, R156.1, U35.8 (V+); also elsewhere on the board
+5V_LOGIC: R137.1, R138.1, R139.1, R154.1, R158.1; also elsewhere on the board
+12V_IN: R151.1; also elsewhere on the board
/23 | Hardware monitoring of 5V and raw 12V/RAIL5_SENSE: R154.2, R155.1, R158.2, U35.5 (+)
/23 | Hardware monitoring of 5V and raw 12V/RAIL12_SENSE: R152.2, R153.1, U35.3 (+)
GND: C154.2, C156.2, R137.2, R138.2, R139.2, R140.2, R153.2, R155.2, R157.2, U35.4 (V-); also elsewhere on the board
unnamed: R151.2, R152.1
RAIL_UV_REF: C156.1, R156.2, R157.1, U35.2 (-), U35.6 (-)
RUN_CLEAR_N: U35.1, U35.7; also elsewhere on the board

Notes on the sheet:
UNIVERSAL POOFER CONTROL | 23 | Hardware monitoring of 5V and raw 12V
REV A.3 | Dry contacts | Latched hardware stop | Buffered expansion
LOGIC-POWERED SUPPLY LOSS DETECTION
Asynchronous RUN clear remains powered when the coil and analog rail disappears
COMMON REFERENCE / LOCAL SUPPLY
5V trip about4.27V;12V trip about8.88V; loss and restoration cannot clock RUN
R65 + R137/R138/R139 = 250ohm total 5V bleed.
Comparator common-mode inputs remain below0.7V, including13.2V raw power, while the3.3V supervisor is valid.
Open-drain outputs sink flip-flop clear;4.7k limits HC02 source current. Real rail ramps and recovery require tests.

Schematic: Source_Feedback_Filters.kicad_sch, 24 | Stable emitter feedback for all wetting sources

Parts:
C141, C142, C143, C144, C145, C146, C147, C148, C149: 100nF; C_0805_2012Metric; MPN CC0805KRX7R9BB104; LCSC C49678
R1024, R1054, R1084, R1114, R1144, R1174, R1204, R1234, R1264: 10k; R_0805_2012Metric; MPN 0805W8F1002T5E; LCSC C17414

Connections:
GND: C141.2, C142.2, C143.2, C144.2, C145.2, C146.2, C147.2, C148.2, C149.2; also elsewhere on the board
IN1_EMIT_F: C141.1, R1024.2; also elsewhere on the board
IN1_WET_EMIT: R1024.1; also elsewhere on the board
IN2_EMIT_F: C142.1, R1054.2; also elsewhere on the board
IN2_WET_EMIT: R1054.1; also elsewhere on the board
IN3_EMIT_F: C143.1, R1084.2; also elsewhere on the board
IN3_WET_EMIT: R1084.1; also elsewhere on the board
IN4_EMIT_F: C144.1, R1114.2; also elsewhere on the board
IN4_WET_EMIT: R1114.1; also elsewhere on the board
IN5_EMIT_F: C145.1, R1144.2; also elsewhere on the board
IN5_WET_EMIT: R1144.1; also elsewhere on the board
IN6_EMIT_F: C146.1, R1174.2; also elsewhere on the board
IN6_WET_EMIT: R1174.1; also elsewhere on the board
IN7_EMIT_F: C147.1, R1204.2; also elsewhere on the board
IN7_WET_EMIT: R1204.1; also elsewhere on the board
IN8_EMIT_F: C148.1, R1234.2; also elsewhere on the board
IN8_WET_EMIT: R1234.1; also elsewhere on the board
IN9_EMIT_F: C149.1, R1264.2; also elsewhere on the board
IN9_WET_EMIT: R1264.1; also elsewhere on the board

Notes on the sheet:
UNIVERSAL POOFER CONTROL | 24 | Stable emitter feedback for all wetting sources
REV A.3 | Dry contacts | Latched hardware stop | Buffered expansion
INPUT 1 | EMITTER FEEDBACK
10k / 100n low-pass removes high-frequency plant gain
INPUT 2 | EMITTER FEEDBACK
INPUT 3 | EMITTER FEEDBACK
INPUT 4 | EMITTER FEEDBACK
INPUT 5 | EMITTER FEEDBACK
INPUT 6 | EMITTER FEEDBACK
INPUT 7 | EMITTER FEEDBACK
INPUT 8 | EMITTER FEEDBACK
INPUT 9 | EMITTER FEEDBACK
Retain the separate OUT-to-IN- compensation. These filters improve illustrative AC phase margin; real parts still require tests.

Board: 4 copper layers, 584 parts (0 on the bottom side), 388 nets, no tracks yet.

Other parts of the board:
FID1, FID2, FID3: 1mm Cu / 2mm mask; Fiducial_1mm_Mask2mm
H1, H2, H3, H4: M3 / 3.2mm; MountingHole_3.2mm_M3

File bom/bom.csv (part):

Reference,Qty,Value,Footprint,MPN,Manufacturer,LCSC,LC_Stock,Chosen_Distributor,Datasheet,Validated,DNP,Notes
"C4,C1,C2,C3,C66",5,10uF / 25V,0805,CL21A106KAYNNNE,Samsung Electro-Mechanics,C15850,3505306,LCSC,https://datasheet.lcsc.com/datasheet/pdf/02336ea48ea44ca18c7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,Package/pin-map checked; prototype pending,,Output effective capacitance>0.5uF required; ceramic stable regulator.
"C5,C40,C7,C8,C9,C131,C132,C133,C134,C135,C136,C137,C138,C139,C80,C81,C82,C83,C84,C90,C91,C92,C110,C111,C112,C113,C74,C75,C70,C71,C72,C154,C141,C142,C143,C144,C145,C146,C147,C148,C149",41,100nF,0805,CC0805KRX7R9BB104,YAGEO,C49678,7277425,LCSC,https://datasheet.lcsc.com/datasheet/pdf/23ccee80ee542e7cf15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,Package/pin-map checked; prototype pending,,Dominant compensation: OUT to isolated local IN-; do not connect directly to global reference.
C6,1,1uF / 50V,0805,CL21B105KBFNNNE,Samsung Electro-Mechanics,C28323,2084641,LCSC,https://datasheet.lcsc.com/datasheet/pdf/02336ea48ea44ca18c7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,Package/pin-map checked; prototype pending,,
"C10,C11,C161,C162,C163,C164,C165,C166,C167,C168,C169",11,1nF / 50V,0805,CL21B102KBANNNC,Samsung Electro-Mechanics,C51210,9257,LCSC,https://datasheet.lcsc.com/datasheet/pdf/02336ea48ea44ca18c7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,Package/pin-map checked; prototype pending,,Absorbs positive FIELD-step charge through the reverse blocker; prevents detector B-E avalanche. Qualify edge timing.
"C50,C55,C60,C101,C102,C103,C104,C105,C106,C107,C108,C109,C156",13,10nF / 50V,0805,CL21B103KBANNNC,Samsung Electro-Mechanics,C1710,1006855,LCSC,https://datasheet.lcsc.com/datasheet/pdf/02336ea48ea44ca18c7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,Package/pin-map checked; prototype pending,,
"D11,D12,D13,D14,D15,D16,D17,D18",8,SS14,SMA,SS14,MDD(Microdiode Semiconductor),C2480,2818967,LCSC,https://datasheet.lcsc.com/datasheet/pdf/9977bb85cd7e349115b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,Package/pin-map checked; prototype pending,,"Relay COIL flyback: cathode+12V, anodeMOSFET drain;~30mA initial current."
"D31,D32,D33,D34,D35,D36,D37,D38",8,SS34,SMA,SS34,MDD(Microdiode Semiconductor),C8678,3557042,LCSC,https://datasheet.lcsc.com/datasheet/pdf/dfa1ff67dea875d0135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,Package/pin-map checked; prototype pending,,"Valve LOAD flyback: cathodeNO, anodeRETURN. External12VDC valve1A max; slow release with diode clamp."
"D41,D42,D43,D44,D45,D46,D47,D48",8,SMBJ8.0A,SMB,SMBJ8.0A,Littelfuse,C224028,1621,LCSC,https://datasheet.lcsc.com/datasheet/pdf/4ab84a227fae39f9eac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,Package/pin-map checked; prototype pending,,
"D91,D21,D22,D23,D24,D25,D26,D27,D28",9,8.2V / 1W,SMA,SMAZ8V2-13-F,DIODES,C84362,1566,LCSC,https://datasheet.lcsc.com/datasheet/pdf/cc6412513453b26615a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,Package/pin-map checked; prototype pending,,
"D111,D112,D113,D114,D115,D116,D117,D118,D101,D121,D102,D122,D103,D123,D104,D124,D105,D125,D106,D126,D107,D127,D108,D128,D109,D129,D119",27,BAS21,SOT-23,"BAS21,215",Nexperia,C8661,221621,LCSC,https://datasheet.lcsc.com/datasheet/pdf/75d45a3e45edceaa3bd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,Package/pin-map checked; prototype pending,,"Nexperia BAS21,215:1anode2NC3cathode. Reverse blocks continuous-100V. Hot leakage bound in manufacturer curve; qualify-40..85C. Do not substitute100V 1N4148."
"D141,D142,D143,D144,D145,D146,D147,D148,D149",9,BAT54,SOT-23,"BAT54,215",Nexperia,C85084,110551,LCSC,https://datasheet.lcsc.com/datasheet/pdf/720f73fc486de0cffc6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,Package/pin-map checked; prototype pending,,Reference-relative clamp protects compensation input during rail loss.
"J1,J2,JP1,J11,J12,J13,J14,J15,J16,J17,J18,J9,J10,J41,J42,J43,J44,J45,J46,J47,J48,JP2",22,2P / 2.54mm,PinHeader_1x02_P2.54mm_Vertical,B-2100S02P-A110,Ckmtw,C124375,71004,LCSC,https://datasheet.lcsc.com/datasheet/pdf/c97166a9fa81fc94cb2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,Package/pin-map checked; prototype pending,,"External regulated 5.0V, >=1A. Do not apply 12V.; 12V coil supply only; ~0.24A for eight relays. Valve power is wired separately per channel.; 5V logic; continuous +/-100V referenced to pin2; no galvanic isolation.; Valve:1positive/switchedNO;2valve-return. RETURN is isolated from logicGND. Wire valve negative here."
"J3,J4,J5",3,20P / 2.54mm,PinHeader_1x20_P2.54mm_Vertical,2.54-1*20P,BOOMELE(Boom Precision Elec),C50981,8114,LCSC,https://datasheet.lcsc.com/datasheet/pdf/d52c83a07830c4e9e9a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,Package/pin-map checked; prototype pending,,"Module pins1-20 in order, 3.3V GPIOs only. Some GPIOs reserved for shift registers.; Module pins21-40 in order. GPIO0/3/45/46 strap levels must be preserved at reset.; Serial bus and relay-driver test/breakout; never drive against MCU or shift-register outputs."
"J6,J7,J31,J32,J33,J34,J35,J36,J37,J38",10,3P / 2.54mm,PinHeader_1x03_P2.54mm_Vertical,B-2100S03P-A110,Ckmtw,C124376,38557,LCSC,https://datasheet.lcsc.com/datasheet/pdf/219f7e7eb5f34457895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,Package/pin-map checked; prototype pending,,"Reset:short1-2. Download:hold3-2 low during reset, then release. Use jumper/buttons externally.; 3.3V UART programmer. Self-powered target; never use5V UART levels.; Relay contacts:1COM2NO3NC; externally feedCOM with fused12V valve supply. <=1A valve design."
J20,1,EXP_UP,PinHeader_2x08_P2.54mm_Vertical,2.54-2*8P针,BOOMELE(Boom Precision Elec),C68234,36548,LCSC,https://datasheet.lcsc.com/datasheet/pdf/d52c83a07830c4e9e9a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,Package/pin-map checked; prototype pending,,"NOPOWERPINS;independentlocalsupplies. Pin11NCcontinuity,terminateonlylast."
J21,1,EXP_DOWN,PinHeader_2x08_P2.54mm_Vertical,2.54-2*8P针,BOOMELE(Boom Precision Elec),C68234,36548,LCSC,https://datasheet.lcsc.com/datasheet/pdf/d52c83a07830c4e9e9a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,Package/pin-map checked; prototype pending,,"NOPOWERPINS;independentlocalsupplies. Pin11NCcontinuity,terminateonlylast."
"K1,K2,K3,K4,K5,K6,K7,K8",8,SRD-12VDC-SL-C,Relay_SPDT_Songle_SRD,SRD-12VDC-SL-C,Songle Relay,C30431,142727,LCSC,https://datasheet.lcsc.com/datasheet/pdf/9ddfe54b7529126320f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,Package/pin-map checked; prototype pending,,Songle12V/360mW coil;400ohm nominal.10A contact rating is resistive. Custom footprint corrects stockSANYOU NC/NO reversal;1COM2/5coil3NC4NO.
"Q40,Q131,Q132,Q133,Q134,Q135,Q136,Q137,Q138,Q139",10,AO3401A,SOT-23,AO3401A,AOS,C15127,715902,LCSC,https://datasheet.lcsc.com/datasheet/pdf/fee353dd1e9e0bc90b2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,Package/pin-map checked; prototype pending,,P-MOS gates local5V bias only.1G2S3D;10k gate-source pullup defaultsOFF on OV or powerloss.
"Q41,Q42,Q111,Q121,Q112,Q122,Q113,Q123,Q114,Q124,Q115,Q125,Q116,Q126,Q117,Q127,Q118,Q128,Q119,Q129",20,MMBT3904,SOT-23,MMBT3904(RANGE:100-300),JSCJ,C20526,2033567,LCSC,https://datasheet.lcsc.com/datasheet/pdf/9335632bcfa83df8351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,Package/pin-map checked; prototype pending,,
"Q101,Q102,Q103,Q104,Q105,Q106,Q107,Q108,Q109",9,MJD350T4G,TO-252-3_TabPin2,MJD350T4G,onsemi,C145514,6132,LCSC,https://datasheet.lcsc.com/datasheet/pdf/e1ca48ba9fe8215bfc4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,Package/pin-map checked; prototype pending,,P-MOS gates local5V bias only.1G2S3D;10k gate-source pullup defaultsOFF on OV or powerloss.
"Q149,Q1,Q2,Q3,Q4,Q5,Q6,Q7,Q8",9,AO3400A,SOT-23,AO3400A,AOS,C20917,1535925,LCSC,https://datasheet.lcsc.com/datasheet/pdf/130876b936da4645994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,Package/pin-map checked; prototype pending,,1Gate2Source3Drain;Rds(on) specified at2.5V gate. Relay coil current~30mA.
"Q151,Q152,Q153,Q154,Q155,Q156,Q157,Q158,Q159",9,MMBT3906,SOT-23,MMBT3906 2A(RANGE:100-300),JSCJ,C2143,77637,LCSC,https://datasheet.lcsc.com/datasheet/pdf/550597da53734df4a72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,Package/pin-map checked; prototype pending,,"Fast backup limiter; senses half of33Rdrop, typically30-50mA surge bound."
"R2,R3,R4,R5,R61,R70,R114,R113,R115,R1020,R1013,R1050,R1043,R1080,R1073,R1110,R1103,R1140,R1133,R1170,R1163,R1200,R1193,R1230,R1223,R1021,R1051,R1081,R1111,R1141,R1171,R1201,R1231,R1261,R1260,R1253,R90,R91,R92,R93,R94,R95,R124,R125,R126,R127,R128,R129,R130,R131,R132,R133,R134,R135,R88,R153,R155,R157,R1024,R1054,R1084,R1114,R1144,R1174,R1204,R1234,R1264",67,10k,0805,0805W8F1002T5E,UNI-ROYAL,C17414,10726008,LCSC,https://datasheet.lcsc.com/datasheet/pdf/0a975aaa49b7c97f38a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,Package/pin-map checked; prototype pending,,Gate-source pullup provides default-off state.
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